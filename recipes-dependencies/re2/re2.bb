require re2.inc