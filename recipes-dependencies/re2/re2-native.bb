require re2.inc

inherit native