require cares.inc

inherit native