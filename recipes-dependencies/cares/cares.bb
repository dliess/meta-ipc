require cares.inc