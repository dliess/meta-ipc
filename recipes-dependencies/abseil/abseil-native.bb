require abseil.inc

inherit native