RDEPENDS_${PN} += "\
        cppzmq-dev \
        zeromq-dev \
        capnproto-dev \
        capnzero-dev \
"